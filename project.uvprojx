# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MB9BF618S Cypress
  pack: Keil.FM3HighPerformance_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WGC_CMM +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: MB9B610S,ARM_MATH_CM3
  c include: .;CMSIS\CM3\CoreSupport;CMSIS\CM3\DeviceSupport\fujitsu\mb9bf61x;applications;components\lwip\src;components\lwip\src\arch\include;components\lwip\src\include;components\lwip\src\include\ipv4;components\lwip\src\include\netif;cpu;drivers;rt-thread\components\finsh;rt-thread\include;CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x64000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  scatter file: .\build\WGC_CMM.sct
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ./applications/: application.c base_task.c eth_callee.c eth_server103.c startup.c uart.c e2timewdg.c rtdboperate.c tcp_debug.c modbus600.c crc.c cmcfgfunc.c confresolve.c modbus611.c nouse_protocol.c modbushfna2s.c
  group CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/fujitsu/mb9bf61x/: system_mb9bf61x.c
    CMSIS/CM3/DeviceSupport/fujitsu/mb9bf61x/startup/arm/: startup_mb9bf61x.S
    ./CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group LwIP
    components/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    components/lwip/src/arch/: sys_arch.c
    components/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    components/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    components/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group Cortex-M3
    cpu/: cpuport.c context_rvds.S
  group Drivers
    ./drivers/: board.c dmac_fm3.c eth_driver.c fm3_emac.c fm3_ext_int_type2.c ports_init.c serial.c sram_value.c
  group Kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group finsh
    rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
software components: CMSIS:CORE 5.0.0
